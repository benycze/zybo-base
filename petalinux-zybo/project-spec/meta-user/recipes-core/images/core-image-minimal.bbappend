IMAGE_INSTALL += "dtc"
