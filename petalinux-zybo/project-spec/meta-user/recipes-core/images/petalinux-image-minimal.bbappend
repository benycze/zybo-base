IMAGE_INSTALL += " dtc"

